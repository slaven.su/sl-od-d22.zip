Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-11-27T01:44:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 27 01:44:35 2020 * Host: comp-63 * Database: C:\Users\TALIPO~1\AppData\Local\Temp\{C2274515-D3E9-4924-B6E9-4C777CCCE463}\ifc * Database version: 5507 * Database creation date: Fri Nov 27 01:44:35 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 27 01:44:35 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 27 01:44:35 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcFlowTerminal: Смеситель_СЛ-ОД-Д22, СЛАВЕН_Смеситель_СЛ_ОД_Д22:Смеситель_СЛ-ОД-Д22:665622
In: Уровень 1
Material: Пластмасса, непрозрачная, черная, СЛАВЕН_Никелированная латунь
Pset_ManufacturerTypeInformation - Manufacturer: ООО «СЛАВЕН»
Pset_DistributionFlowElementCommon - Reference: Смеситель_СЛ-ОД-Д22
